# IAR project STM32 Firmwareupdate.ewp, settings and files
configuration STM32 Firmwareupdate (ARM, debug)
  General.OGChipSelectEditMenu: STM32H503RB ST STM32H503RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H503xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc; ../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H5xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32 Firmwareupdate.hex
  ILINK.IlinkOutputFile: STM32 Firmwareupdate.out
  ILINK.IlinkIcfFile: stm32h503xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h503xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_cortex.c stm32h5xx_hal_icache.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
